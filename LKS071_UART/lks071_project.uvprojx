# Keil uVision project lks071_project.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: LKS32MC071C8T8 Linko
  pack: Linko.LKS07x.1.2.0
  cpu: IRAM(0x20000000,0x3000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lks071_project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Include;.\lks32mc07x_periph_driver\include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Periph_Driver
    ./lks32mc07x_periph_driver/source/: lks32mc07x_gpio.c lks32mc07x_sys.c lks32mc07x_nvr.lib
    ../../LKS071_GPIO_Test/lks32mc07x_periph_driver/source/: lks32mc07x_tim.c lks32mc07x_uart.c
  group AppFunction
    ./Kernel_Source/: main.c
    ./AppFunction/: hardware_init.c interrupt.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
